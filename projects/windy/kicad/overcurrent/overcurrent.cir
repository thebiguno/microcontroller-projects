* EESchema Netlist Version 1.1 (Spice format) creation date: Tuesday, March 31, 2015 'amt' 09:35:41 am

* To exclude a component from the Spice Netlist add [Spice_Netlist_Enabled] user FIELD set to: N
* To reorder the component spice node sequence add [Spice_Node_Sequence] user FIELD and define sequence: 2,1,0

*Sheet Name:/
R17  /BATTERY /VBATT 20k
R18  /VBATT GND 10k
J1  /REGULATED_LOAD Net-_J1-Pad2_ Net-_J1-Pad3_ GND GND GND USB
R21  Net-_J1-Pad2_ Net-_J1-Pad3_ 100
RV1  VCC Net-_DS1-Pad3_ GND 10K
P2  ? Net-_P2-Pad2_ /MOSI VCC Net-_P2-Pad5_ GND Net-_P2-Pad7_ ? SD_CARD
U5  Net-_U5-Pad1_ Net-_U5-Pad2_ ? GND /SDA /SCL ? VCC DS1307
X1  Net-_U5-Pad1_ Net-_U5-Pad2_ 32.768kHz
U1  /TACH GND Net-_C1-Pad2_ VCC Net-_R16-Pad1_ /CURR /CURR GND LM324
C1  GND Net-_C1-Pad2_ 1u
R2  Net-_C1-Pad2_ GND 10k
R1  Net-_C1-Pad2_ /AC1 20k
R5  VCC /RESET 10k
R13  /SDA VCC 10k
R12  /SCL VCC 10k
BR1  /SOURCE /AC3 /AC2 /AC1 GND FUS45-0045B
C11  VCC GND .1u
VR1  /BATTERY GND VCC LM7805CT
DS1  GND VCC Net-_DS1-Pad3_ /MOSI GND /LCD_E ? ? ? ? /D4 /D5 /D6 /D7 Net-_DS1-Pad15_ GND HD44780
R22  Net-_DS1-Pad15_ /LCD_BL 1k
C3  GND Net-_C3-Pad2_ 0.1u
U4  GND /SD_CS Net-_P2-Pad2_ GND /SCLK Net-_P2-Pad5_ GND Net-_P2-Pad7_ /MISO GND VCC 74LS125
U3  Net-_R16-Pad1_ GND /SWITCHED_SOURCE /BATTERY VCC INA169
P1  /MOSI /SCLK /RESET VCC /MOSI GND ISP
TB1  /AC1 /AC2 /AC3 STATOR
TB4  /BATTERY GND BATTERY
TB3  /DUMP_LOAD GND DUMP
R15  /BATTERY /SWITCHED_SOURCE 0.1Ω 1% 5W
C10  VCC GND 0.1u
R16  Net-_R16-Pad1_ GND 10k 1%
TB5  /SWITCHED_LOAD GND LOAD
TB2  GND /SOURCE PVP
D3  /FUSED_SOURCE /FILTERED_SOURCE IN4007
R8  /FILTERED_SOURCE /VIN 20k
R9  /VIN GND 10k
R11  Net-_D4-Pad1_ /CHARGE_SW 1k
C7  /FILTERED_SOURCE GND 100uF, 35V
Q2  /FILTERED_SOURCE Net-_D4-Pad1_ /SWITCHED_SOURCE IRF540N
F2  /BATTERY /FUSED_LOAD FUSE
R20  Net-_D5-Pad1_ /LOAD_SW 1k
F1  /SOURCE /FUSED_SOURCE FUSE
U2  ? VCC /D- /D+ GND Net-_C2-Pad2_ Net-_CON1-Pad1_ /SD_CS /SCLK /MOSI /MISO ? /RESET VCC GND ? ? /SCL /SDA /TACH ? /D5 GND VCC /D4 /D6 /D7 /LOAD_SW /DUMP_SW /CHARGE_SW /LCD_E /LCD_BL Net-_R14-Pad1_ VCC GND /ENC_SW /ENC_B /ENC_A /CURR /VBATT /VIN Net-_C3-Pad2_ GND VCC ATMEGA32U4-A
SW2  Net-_R14-Pad1_ GND HWB
C2  GND Net-_C2-Pad2_ 0.1u
C4  VCC GND .1u
C5  VCC GND .1u
C6  VCC GND .1u
C8  VCC GND .1u
R14  Net-_R14-Pad1_ VCC 10k
SW1  GND /RESET RESET
R3  /D+ Net-_CON1-Pad3_ 22
R4  /D- Net-_CON1-Pad2_ 22
CON1  Net-_CON1-Pad1_ Net-_CON1-Pad2_ Net-_CON1-Pad3_ ? GND GND GND GND GND USB-MINI-B
D1  Net-_D1-Pad1_ Net-_D1-Pad2_ LED
D4  Net-_D4-Pad1_ Net-_D4-Pad2_ LED
R6  Net-_D1-Pad2_ GND 1k
R10  Net-_D4-Pad2_ GND 1k
Q1  /SOURCE Net-_D1-Pad1_ /DUMP_LOAD IRF540N
R7  Net-_D1-Pad1_ /DUMP_SW 1k
P3  /ENC_A GND /ENC_B GND /ENC_SW ENCODER
C9  /SWITCHED_SOURCE GND 100uF, 35V
D5  Net-_D5-Pad1_ Net-_D5-Pad2_ LED
Q3  /FUSED_LOAD Net-_D5-Pad1_ /SWITCHED_LOAD IRF540N
R19  Net-_D5-Pad2_ GND 1k
C12  /BATTERY GND 470uF, 35V
D2  /SOURCE /FUSED_SOURCE GND TVS
D6  ? /SWITCHED_LOAD GND TVS
D8  /ENC_A /ENC_B GND TVS
D7  /REGULATED_LOAD /ENC_SW GND TVS
D9  /SCL /SDA GND TVS
D10  /D+ /D- GND TVS
VR2  /SWITCHED_LOAD GND /REGULATED_LOAD LM7805CT

.end
